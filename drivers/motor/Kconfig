## drivers/motor/Kconfig
```kconfig
#
#
#
menuconfig VIBETONZ
	tristate "Vibetonz"
	default y
	help
		Say Y to enable Vibetonz support.
```
